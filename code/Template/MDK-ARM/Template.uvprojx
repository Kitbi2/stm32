# Keil uVision project Template.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE,HAL_USART_MODULE_ENABLED,HAL_UART_MODULE_ENABLED,HAL_DMA_MODULE_ENABLED,HAL_TIM_MODULE_ENABLED,HAL_PWR_MODULE_ENABLED,HAL_RTC_MODULE_ENABLED,HAL_ADC_MODULE_ENABLED,HAL_I2C_MODULE_ENABLED,HAL_SPI_MODULE_ENABLED,HAL_SRAM_MODULE_ENABLED,HAL_NOR_MODULE_ENABLED
  c misc: --locale=english
  c include: ..\Core;..\Driver\Inc;..\Driver\Inc\Legacy;..\CMSIS\Include;..\CMSIS\Device\ST\STM32F1xx\Include;..\BSP;.\Mid_Lvgl;.\Mid_Lvgl\driver\porting;.\Mid_Lvgl\src;.\Mid_LvgI\src\core;.\Mid_LvgI\src\draw;.\Mid_Lvgl\src\extra;.\Mid_Lvgl\src\extra\layouts;.\Mid_Lvgl\src\extra\layouts\flex;.\Mid_Lvgl\src\extra\layouts\grid;.\Mid_Lvgl\src\extra\themes;.\Mid_Lvgl\src\extra\themes\basic;.\Mid_LvgI\src\extra\themes\default;.\Mid_Lvgl\src\extra\themes\mono;.\Mid_Lvgl\src\extra\widgets;.\Mid_Lvgl\src\extra\widgets\animimg;.\Mid_Lvgl\src\extra\widgets\calendar;.\Mid_Lvgl\src\extra\widgets\chart;.\Mid_Lvgl\src\extra\widgets\colorwheel;.\Mid_Lvgl\src\extra\widgets\imgbtn;.\Mid_LvgI\src\extra\widgets\keyboard;.\Mid_Lvgl\src\extra\widgets\led;.\Mid_Lvgl\src\extra\widgets\list;.\Mid_Lvgl\src\extra\widgets\menu;.\Mid_Lvgl\lsrc\extra\widgets\meter;.\Mid_Lvgl\src\extra\widgets\msgbox;.\Mid_Lvgl\src\extra\widgets\span;.\Mid_Lvgl\src\extra\widgets\spinblox;.\Mid_LvgI\src\extra\widgets\spinner;.\Mid_LvgI\src\extra\widgets\tabview;.\Mid_LvgI\src\extra\widgets\tileview;.\Mid_LvgI\src\exltra\widgets\win;.\Mid_Lvgl\src\font;.\Mid_Lvgl\src\hal;.\Mid_Lvgl\src\misc;.\Mid_Lvgl\src\widgets;..\Mid_lvgl;..\Mid_lvgl\examples\driver;..\BSP\widgets;..\BSP\widgets\assets
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Core
    ../Core/: startup_stm32f103xe.s stm32f1xx_clk.c stm32f1xx_clk.h stm32f1xx_hal_conf.h stm32f1xx_it.c stm32f1xx_it.h system_stm32f1xx.c
  group USER
    ../User/: main.c
  group Dirver
    ../Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_dma.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_i2c.c stm32f1xx_hal_spi.c stm32f1xx_hal_sram.c stm32f1xx_hal_nor.c stm32f1xx_ll_fsmc.c
  group BSP
    ../BSP/: delay.c delay.h led_driver.c led_driver.h KEY.c KEY.h Systick.c Systick.h USBtoCom.c USBtoCom.h USBtoComApp.c USBtoComApp.h queue.c queue.h tim_driver.c tim_driver.h pwm_driver.c pwm_driver.h Calendar.c Calendar.h secor.c secor.h Temp.c Temp.h Parse.c Parse.h Him.c Him.h IIC.c IIC.h at24c02.c at24c02.h AP3426.c AP3426.h noFlash.c noFlash.h ICM20608.c ICM20608.h SPI.c SPI.h FSMC.c FSMC.h LCD.c LCD.h PIC.c XPT2046.c XPT2046.h light.c lrda.c tmp.c lv_font_sy_24.c siyuan_24.c
    ../BSP/widgets/: lv_demo_widgets.c
    ../BSP/widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_lvgl_logo.c
  group Mid_lvgl/core
    ../Mid_lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group Mid_lvgl/extra
    ../Mid_lvgl/src/extra/layouts/flex/: lv_flex.c
    ../Mid_lvgl/src/extra/layouts/grid/: lv_grid.c
    ../Mid_lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../Mid_lvgl/src/extra/themes/default/: lv_theme_default.c
    ../Mid_lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../Mid_lvgl/src/extra/: lv_extra.c
    ../Mid_lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../Mid_lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Mid_lvgl/src/extra/widgets/chart/: lv_chart.c
    ../Mid_lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../Mid_lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../Mid_lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../Mid_lvgl/src/extra/widgets/led/: lv_led.c
    ../Mid_lvgl/src/extra/widgets/list/: lv_list.c
    ../Mid_lvgl/src/extra/widgets/menu/: lv_menu.c
    ../Mid_lvgl/src/extra/widgets/meter/: lv_meter.c
    ../Mid_lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../Mid_lvgl/src/extra/widgets/span/: lv_span.c
    ../Mid_lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../Mid_lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../Mid_lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../Mid_lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../Mid_lvgl/src/extra/widgets/win/: lv_win.c
  group Mid_lvgl/font
    ../Mid_lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group Mid_lvgl/hal
    ../Mid_lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group Mid_lvgl/misc
    ../Mid_lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group Mid_lvgl/widgets
    ../Mid_lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
    ../Mid_lvgl/examples/driver/: lv_port_disp.c lv_port_indev.c
  group Mid_lvgl/draw
    ../Mid_lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../Mid_lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
