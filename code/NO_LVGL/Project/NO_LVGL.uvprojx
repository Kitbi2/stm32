# Keil uVision project NO_LVGL.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: NO_LVGL +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE,HAL_USART_MODULE_ENABLED,HAL_DMA_MODULE_ENABLED,HAL_TIM_MODULE_ENABLED,HAL_UART_MODULE_ENABLED,HAL_RTC_MODULE_ENABLED,HAL_PWR_MODULE_ENABLED,HAL_SPI_MODULE_ENABLED,HAL_SD_MODULE_ENABLED
  c include: ..\BSP;..\CMSIS\Include;..\CMSIS\Device\ST\STM32F1xx\Include;..\Core;..\HAL_Driver\Inc;..\HAL_Driver\Inc\Legacy;..\Drv_Modbus;..\Mid_Modbus;..\Mid_Modbus\include;..\Mid_Modbus\rtu;..\Fatfs;..\APP;..\MQTT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Core
    ../Core/: stm32f1xx_clk.c stm32f1xx_it.c system_stm32f1xx.c startup_stm32f103xe.s
  group BSP
    ../BSP/: delay.c InFared.c led_driver.c queue.c Systick.c USBtoCom.c USBtoComApp.c IIC.c at24c02.c KEY.c noFlash.c SPI.c Calendar.c app.c sdio_sdcard.c ESP8266.c
  group HAL_Driver
    ../HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_cortex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_spi.c stm32f1xx_hal_sd.c stm32f1xx_ll_sdmmc.c
  group User
    ../User/: main.c
  group FatFs
    ../Fatfs/: diskio.c ff.c ffsystem.c ffunicode.c
  group Mid_ModBus
    ../Mid_Modbus/functions/: mbfuncholding.c mbutils.c
    ../Mid_Modbus/rtu/: mbcrc.c mbrtu.c
    ../Mid_Modbus/: mb.c modbus_slave.c
  group Drv_ModBus
    ../Drv_Modbus/: portevent.c portserial.c porttimer.c
  group APP
    ../APP/: wifi_app.c
software components: Compiler:I/O:STDERR 1.0.0
